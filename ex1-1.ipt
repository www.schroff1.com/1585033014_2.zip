# Autodesk Inventor part: ex1-1
## iProperties
Created: 2006-03
Part Number: ex1-1
Document SubType Name: Modeling
Designer: Elise Moss
Author: Elise Moss
## Feature names
1. Extrusion1
