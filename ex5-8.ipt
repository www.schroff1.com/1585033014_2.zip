# Autodesk Inventor part: ex5-8
## iProperties
Created: 2006-03
Part Number: ex5-8
Document SubType Name: Modeling
Designer: Elise Moss
Author: Elise Moss
## Feature names
1. Loft1
