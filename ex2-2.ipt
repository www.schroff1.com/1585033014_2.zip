# Autodesk Inventor part: ex2-2
## iProperties
Created: 2006-03
Part Number: ex2-2
Document SubType Name: Modeling
Designer: Elise Moss
Author: Elise Moss
## Feature names
1. Extrusion1
