# Autodesk Inventor part: ex5-3
## iProperties
Created: 2006-03
Part Number: ex5-3
Document SubType Name: Modeling
Designer: Elise Moss
Author: Elise Moss
## Feature names
1. Revolution1
2. Hole1
