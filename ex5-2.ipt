# Autodesk Inventor part: ex5-2
## iProperties
Created: 2006-03
Part Number: ex5-2
Document SubType Name: Modeling
Designer: Elise Moss
Author: Elise Moss
## Feature names
1. Extrusion1
2. Hole1
