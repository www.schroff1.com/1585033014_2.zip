# Autodesk Inventor part: ex5-20
## iProperties
Created: 2006-03
Part Number: ex5-20
Document SubType Name: Modeling
Designer: Elise Moss
Author: Elise Moss
## Feature names
1. Loft1
2. Mirror1
