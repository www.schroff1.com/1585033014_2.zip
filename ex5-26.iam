# Autodesk Inventor assembly: ex5-26
## iProperties
Created: 2006-03
Part Number: ex5-26
Document SubType Name: Assembly
Designer: Elise Moss
Author: Elise Moss
